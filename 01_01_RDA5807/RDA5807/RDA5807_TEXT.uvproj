# Keil uVision project RDA5807_TEXT.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: RDA5807_TEXT +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Listings\I2C;.\Listings\MAIN;.\Listings\RDA5807;.\Listings\System;.\Listings\NUMLED
  group Source Group 1
    ./Listings/MAIN/: main.c
    ./Listings/I2C/: I2C.C
    ./Listings/System/: Delay.c UART.c
    ./Listings/RDA5807/: RDA5807.C
    ./Listings/NUMLED/: NUMLED.c
