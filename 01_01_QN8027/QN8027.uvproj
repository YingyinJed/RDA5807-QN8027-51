# Keil uVision project QN8027.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: QN8027 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\MAIN;.\I2C;.\QN8027;.\System;.\NUMLED
  group Source Group 1
    ./MAIN/: main.c
    ./I2C/: I2C.C
    ./QN8027/: QN8027.c
    ./System/: Delay.c
    ./NUMLED/: NUMLED.c
